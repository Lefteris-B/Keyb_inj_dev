# Repository Lefteris-B/Keyb_inj_dev

File README.md:

# Keyb_inj_dev
Εργασία Κατασκευή ενός Keyboard injection device για το μάθημα <<Ασφάλεια Πληροφοριακών Συστημάτων και Επικοινωνιών>>

## KiCad design shematics/badusb.kicad_pcb

Board: 2 copper layers, 15.0 x 31.0 mm, 25 parts (15 on the bottom side), 22 nets.

Parts:
C1, C2, C8: 10uF; C_0805_2012Metric
C3, C6, C7, C9, C10, C12: 100nF; C_0603_1608Metric
C4, C5, C11: 18pF; C_0603_1608Metric
CON1: ST-LINK_V2; PinHeader_1x05_P2.54mm_Vertical
D1: GREEN; LED_0603_1608Metric
J1: USB_A_Plug; USB_A_CNCTech_1001-011-01101_Horizontal
R1, R2: 33; R_0603_1608Metric
R3, R4: 4.7k; R_0603_1608Metric
SW1: TL3342; SW_SPST_TL3342
U1: IP4220CZ6; TSOP-6_1.65x3.05mm_P0.95mm
U2: MCP1700-3302E/TT; SOT-23
U3: STM32F072C8Tx; LQFP-48_7x7mm_P0.5mm
U4: W25N01GVZEIG; WSON-8_8x6mm
Y1: 8MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm

Connections:
3.3V: C2.1, C3.2, C6.2, C7.2, C8.1, C9.1, CON1.4, U2.2, U3.1, U3.9, U3.24, U3.36, U3.48, U4.8
5V: C1.1, J1.1, U1.5, U2.3
GND: C1.2, C2.2, C3.1, C4.2, C5.2, C6.1, C7.1, C8.2, C9.2, C10.1, C11.2, C12.1, CON1.3, J1.4, J1.5, R3.1, R4.2, SW1.2, U1.2, U2.1, U3.2, U3.8, U3.23, U3.28, U3.30, U3.35, U3.39, U3.41, U3.47, U4.4, U4.9
unnamed: C4.1, U3.5, Y1.1
unnamed: C5.1, U3.6, Y1.2
unnamed: C10.2, SW1.1, U3.12
unnamed: D1.1, R4.1
unnamed: D1.2, U3.43
unnamed: R2.2, U3.34
boot0: C12.2, CON1.5, R3.2, U3.44
cs: U3.19, U4.1
d+: J1.3, U1.3, U3.33
d-: J1.2, U1.4, U3.32
hold: U3.13, U4.7
miso: U3.16, U3.21, U4.2
mosi: U3.17, U4.5
nc1: R1.2, U3.26, U3.37
nrst: C11.1, U3.4, U3.7
sck: U3.15, U4.6
swclk: CON1.1, R1.1, U1.6
swdio: CON1.2, R2.1, U1.1
wp: U3.22, U4.3

## Commit log

2020-10-08 Rename badusb.sch to shematics/badusb.sch
